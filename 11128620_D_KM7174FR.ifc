Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2019-04-17T09:25:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20160225_1515(x64) - Exporter 17.0.416.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Apr 17 09:25:50 2019 * Host: DEGTL09122 * Database: C:\Users\deschvi\AppData\Local\Temp\{F7F7AE96-768D-48F1-9FAB-C69BEB302853}\ifc * Database version: 5507 * Database creation date: Wed Apr 17 09:25:48 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Apr 17 09:25:49 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Apr 17 09:25:49 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 26717400_D_11128620_KM7174FR, 11128620_D_KM7174FR:26717400_D_11128620_KM7174FR:205550
In: Level 1
Type - Classification: A-KM-7000 (Uniformat); Material: z_Miele_Design_Glass Black, z_Miele_Design_Stainless Steel, z_Miele_Connection_Electric, Default, z_Miele_Design_CLST
Pset_BuildingElementProxyCommon - Reference: 26717400_D_11128620_KM7174FR
Pset_ManufacturerTypeInformation - Manufacturer: Miele
